<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SimplDMA_EXHS.ewp</path>
    </project>
    <batchBuild />
</workspace>
