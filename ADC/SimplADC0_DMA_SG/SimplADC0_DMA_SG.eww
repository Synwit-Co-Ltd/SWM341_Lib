<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SimplADC0_DMA_SG.ewp</path>
    </project>
    <batchBuild />
</workspace>
