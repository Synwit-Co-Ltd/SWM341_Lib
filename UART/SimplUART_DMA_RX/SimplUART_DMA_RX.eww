<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SimplUART_DMA_RX.ewp</path>
    </project>
    <batchBuild />
</workspace>
