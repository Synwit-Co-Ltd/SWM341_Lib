<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SDCard_FATFS.ewp</path>
    </project>
    <batchBuild />
</workspace>
