<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SimplSPI_Interrupt_TX.ewp</path>
    </project>
    <batchBuild />
</workspace>
