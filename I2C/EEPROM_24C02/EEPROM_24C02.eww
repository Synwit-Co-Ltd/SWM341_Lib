<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EEPROM_24C02.ewp</path>
    </project>
    <batchBuild />
</workspace>
