# IAR project SimplFIR.ewp, settings and files
configuration SWM341 (ARM, debug)
  General.OGChipSelectEditMenu: SWM341xE Synwit SWM341xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; ARM_MATH_ROUNDING; ARM_MATH_MATRIX_CHECK
  ICCARM.CCIncludePath2: ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver; ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\DSP_Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; ARM_MATH_ARMV8MML; __CC_ARM
  OBJCOPY.OOCOutputFile: SimplFIR.srec
  ILINK.IlinkOutputFile: SimplFIR.out
  group APP
    ./app/: main.c
    ./APP/: math_helper.c
  group CSL\StdPD
    ../../SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_exti.c SWM341_gpio.c SWM341_i2c.c SWM341_pwm.c SWM341_timr.c SWM341_uart.c SWM341_wdt.c SWM341_dma.c SWM341_flash.c SWM341_port.c SWM341_spi.c SWM341_can.c SWM341_crc.c SWM341_lcd.c SWM341_rtc.c
  group CSL\CMSIS
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM341.s
  group DSP/BASIC
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
  group DSP/CONST
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/CommonTables/: arm_common_tables.c arm_const_structs.c
  group DSP/FILTER
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q7.c arm_conv_opt_q15.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q7.c arm_conv_partial_opt_q15.c arm_conv_partial_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_q7.c arm_conv_q15.c arm_conv_q31.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q7.c arm_correlate_opt_q15.c arm_correlate_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q7.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q7.c arm_fir_q15.c arm_fir_q31.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q7.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group DSP/MATRIX
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group DSP/COMPLEX
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group DSP/CONTROL
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group DSP/SUPPORT
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
  group DSP/FASTMATH
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group DSP/STATISTIC
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group DSP/TRANSFORM
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DSP_Src/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c arm_cfft_f64.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_rfft_fast_f64.c arm_rfft_fast_init_f64.c arm_bitreversal2.c
