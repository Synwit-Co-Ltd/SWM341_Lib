<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SimplLCD_RGB_Layer.ewp</path>
    </project>
    <batchBuild />
</workspace>
