# IAR project uCOS-II.ewp, settings and files
configuration SWM341 (ARM, debug)
  General.OGChipSelectEditMenu: SWM341xE Synwit SWM341xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver; .\APP; .\APP\uCOS; .\APP\uCOS\Ports\ARMv7-M\GNU
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: uCOS-II.srec
  ILINK.IlinkOutputFile: uCOS-II.out
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv7-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv7-M/GNU/: os_cpu_a.S
  group CSL\StdPD
    ../../SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_exti.c SWM341_gpio.c SWM341_i2c.c SWM341_pwm.c SWM341_timr.c SWM341_uart.c SWM341_wdt.c SWM341_dma.c SWM341_flash.c SWM341_port.c SWM341_spi.c SWM341_can.c SWM341_crc.c SWM341_lcd.c SWM341_rtc.c
  group CSL\CMSIS
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM341.s
