# IAR project SWM341_StdPeriph_Driver.ewp, settings and files
configuration SWM341 (ARM, debug)
  General.OGChipSelectEditMenu: SWM341xE Synwit SWM341xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM341_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: SWM341_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: SWM341_StdPeriph_Driver.out
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_port.c SWM341_gpio.c SWM341_exti.c SWM341_timr.c SWM341_uart.c SWM341_adc.c SWM341_dma.c SWM341_i2c.c SWM341_pwm.c SWM341_can.c SWM341_spi.c SWM341_lcd.c SWM341_flash.c SWM341_crc.c SWM341_rtc.c SWM341_wdt.c SWM341_cordic.c SWM341_sleep.c SWM341_usbd.c SWM341_div.c SWM341_sdio.c SWM341_sdram.c SWM341_dac.c SWM341_jpeg.c SWM341_sfc.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM341.s
